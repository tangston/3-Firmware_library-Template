# Keil uVision project HNUST-F103.uvprojx, settings and files
target HNUST-103 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HNUST-F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F103xx
  c include: ..\Libraries\Cortex_Microcontroller_Software_Interface_Standard\startup;..\Libraries\stm32f10x_peripheral_driver\include;..\Libraries\stm32f10x_peripheral_driver\source;..\user;..\Libraries\Cortex_Microcontroller_Software_Interface_Standard;..\user\board_support_package
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../Libraries/Cortex_Microcontroller_Software_Interface_Standard/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/Cortex_Microcontroller_Software_Interface_Standard/: system_stm32f10x.c core_cm3.c
  group FWlib
    ../Libraries/stm32f10x_peripheral_driver/source/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group user
    ../user/: main.c stm32f10x_it.c
    ../user/board_support_package/: bsp_led.c bsp_key.c
